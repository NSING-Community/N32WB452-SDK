# Keil uVision project slave_ota_app.uvprojx, settings and files
target slave_ota_app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ble_ota
  AfterMake: fromelf --bin --output .\ble_ota.bin .\Objects\ble_ota.axf
  AfterMake: .\__Get_OTA_Info.exe
  c flags: uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: N32WB452, USE_STDPERIPH_DRIVER,N32WB452_BT_API,BD_RTC_USE_LSI,BLE_OTA_WRITE_CHAR_EN
  c misc: --wchar32
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\btapi\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\profile\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\platform\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver;..\inc;..\src\bsp;..\src\api\inc;..\..\..\..\bsp\inc;..\src\ota\;..\src\ota\crc16;..\src\ota\encrypt;..\src\ota\sha1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\slave_ota_app.sct
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_exti.c n32wb452_gpio.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_tim.c n32wb452_usart.c n32wb452_spi.c n32wb452_adc.c n32wb452_dbg.c n32wb452_rtc.c n32wb452_bkp.c n32wb452_flash.c
  group USER
    ../src/: main.c n32wb452_it.c n32wb452_w25qxx.c
  group BSP
    ../../../../bsp/src/: log.c
    ../src/bsp/: bsp_timer.c bsp_spi.c
  group BT_API
    ../src/api/src/: n32wb452_data_fifo.c
    ../../../../../../firmware/n32wb452_ble_driver/: n32wb452_ble_api.c
  group BT_PROFILE
    ../../../../../../firmware/n32wb452_ble_driver/profile/: app.c app_batt.c app_sec.c app_task.c app_user.c bass.c bass_task.c prf.c prf_utils.c user.c user_task.c
  group BT_PLATFORM
    ../../../../../../firmware/n32wb452_ble_driver/platform/: Eif_debug.c Eif_flash.c Eif_timer.c Interface.c
  group OTA
    ../src/ota/: n32wb452_ble_ota_api.c n32wb452_ble_protocol.c n32wb452_ota_iap.c n32wb452_ota_upgrade.c
    ../src/ota/sha1/: sha1.c
    ../src/ota/encrypt/: ble_encrypt_interface.c encrypt_app_interface.c SecuritySM4.c sm4.c
    ../src/ota/crc16/: CRC16.c
  group BT_BLE_LIB
    ../../../../../../firmware/n32wb452_ble_driver/lib/Keil/: host.lib host_16bit.lib n32wb452_ble.lib n32wb452_ble_16bit.lib
  group DOC
    ../: readme.txt
target slave_ota_app_16bit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.1
  cpu: as above
  output: ble_ota
  AfterMake: fromelf --bin --output .\ble_ota.bin .\Objects\ble_ota.axf
  AfterMake: .\__Get_OTA_Info.exe
  c flags: uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: as above
  c misc: --wchar16
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\slave_ota_app.sct
