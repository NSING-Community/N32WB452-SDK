# IAR project devDemo.ewp, settings and files
configuration DevDemo_16bit (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452LE Nations N32WB452LE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER; N32WB452_BT_API; BD_RTC_USE_LSI; WCHAR16; __IAR_ARM; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32wb452_std_periph_driver/inc; ../../../../../../firmware/n32wb452_ble_driver/inc; ../../../../../../firmware/n32wb452_ble_driver/btapi/inc; ../../../../../../firmware/n32wb452_ble_driver/profile/inc; ../../../../../../firmware/n32wb452_ble_driver/platform/inc; ../../../../../../firmware/n32wb452_ble_driver/; ../inc; ../src/bsp; ../src/lcd; ../src/gsensor; ../src/lcd/Fonts; ../src/hdc2010; ../src/api/inc; ../../../../bsp/inc; ..\..\..\..\..\..\firmware\n32wb452_ble_driver\lib\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: devDemo.srec
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: n32wb452_dev.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32wb452_ble_driver\lib\IAR\host.a; ..\..\..\..\..\..\firmware\n32wb452_ble_driver\lib\IAR\n32wb452_ble.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DevDemo (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32wb452_std_periph_driver/inc; ../../../../../../firmware/n32wb452_ble_driver/inc; ../../../../../../firmware/n32wb452_ble_driver/btapi/inc; ../../../../../../firmware/n32wb452_ble_driver/profile/inc; ../../../../../../firmware/n32wb452_ble_driver/platform/inc; ../../../../../../firmware/n32wb452_ble_driver/; ../inc; ../src/bsp; ../src/lcd; ../src/gsensor; ../src/lcd/Fonts; ../src/hdc2010; ../src/api/inc; ../../../../bsp/inc
  group BSP
    ../src/bsp/: bsp_adc.c bsp_spi.c bsp_timer.c
  group BT_API
    ../../../../../../firmware/n32wb452_ble_driver/: n32wb452_ble_api.c
    ../src/api/src/: n32wb452_data_fifo.c
  group BT_PLATFORM
    ../../../../../../firmware/n32wb452_ble_driver/platform/: Eif_debug.c Eif_flash.c Eif_timer.c Interface.c
  group BT_PROFILE
    ../../../../../../firmware/n32wb452_ble_driver/profile/: app.c app_batt.c app_sec.c app_task.c app_user.c bass.c bass_task.c prf.c prf_utils.c user.c user_task.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_adc.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_i2c.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_spi.c n32wb452_tim.c n32wb452_usart.c
  group GSENSOR
    ../src/gsensor/: gsensor.c qma_i2c_drv.c
  group HDC2010
    ../src/hdc2010/: HDC2010.c hdc_i2c_drv.c
  group LCD
    ../src/lcd/Fonts/: font24.c
    ../src/lcd/: lcd_display.c lcd_drv.c lcd_gui.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../../../../bsp/src/: log.c
    ../src/: main.c n32wb452_it.c
