# Keil uVision project ALGO_Demo.uvprojx, settings and files
target N32WB452 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.1.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ALGO_Demo +hex
  AfterMake: fromelf --bin --output=.\bin\ALGO_Demo.bin .\Objects\ALGO_Demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32wb452_algo_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_usart.c n32wb452_flash.c
  group USER
    ../src/: main.c n32wb452_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group ALGO
    ../../../../../../firmware/n32wb452_algo_lib/lib/: n32wb452_aes.lib n32wb452_algo_common.lib n32wb452_des.lib n32wb452_hash.lib n32wb452_rng.lib n32wb452_aes_wchar32.lib n32wb452_algo_common_wchar32.lib n32wb452_des_wchar32.lib n32wb452_hash_wchar32.lib n32wb452_rng_wchar32.lib
  group DOC
    ../: readme.txt
target N32WB452_wchar32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.1.0
  cpu: as above
  output: ALGO_Demo +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER
  c misc: --wchar32
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32wb452_algo_lib\inc;..\..\..\..\..\..\firmware\n32wb452_algo_lib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
