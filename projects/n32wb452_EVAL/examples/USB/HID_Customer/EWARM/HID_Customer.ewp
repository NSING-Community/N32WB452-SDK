# IAR project HID_Customer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452LE Nations N32WB452LE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT=1; __IAR_ARM
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc; ..\..\..\..\..\..\firmware\n32wb452_usbfs_driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_Customer.bin
  ILINK.IlinkOutputFile: HID_Customer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_dac.c n32wb452_dma.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_tim.c n32wb452_usart.c
  group n32wb452_usbfs_driver
    ../../../../../../firmware/n32wb452_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../src/: hw_config.c main.c n32wb452_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
